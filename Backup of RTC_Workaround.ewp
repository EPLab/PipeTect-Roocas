# IAR project Backup of RTC_Workaround.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlfn.h
  General.OGChipSelectMenu: MSP430F5438 MSP430F5438
  General.GStackSize2: 320
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: x__FILE_SAVE_ENABLED__; __DMA_MMC_ENABLED__; __DMA_MMC_ESSENTIAL_ONLY__; x__MMC_INFO_GEN_ENABLED__; xFRAM_ENABLED; xFRAM_METADATA_CACHE_ENABLED; x__LOCAL_STORE_ENABLED__; x__LOCAL_STORE_ACCEL_MODE__; xPROBE_ENABLED; __ROOCAS2
  ICC430.newCCIncludePaths: $PROJ_DIR$; DMA_FAT
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: CC430F5133 CC430F5133
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group APP
    ./: acc.c acc.h acc_gbl.c
  group DRIVERS
    ./: cam.c cam.h gps.c gps.h rfm.c rfm.h rtc.c rtc.h uif.c uif.h utx.c utx.h wwvb.c wwvb.h xbee.c xbee.h xstream.c xstream.h
  group DRIVERS/CAN
    ./: can.c can.h can_flags.h can_recv_queue.c can_recv_queue.h can_reg.h
  group DRIVERS/WIFI
    ./: redpine.c redpine.h wifi.c wifi.h
  group FS/EXECUTIVES
    ./: local_store.c local_store.h
  group FS/FAT32
    DMA_FAT/: fat32_directory_entry.h fat32_fsinfo.h fat32_pbr.h fat_access.c fat_access.h fat_defs.h fat_filelib.c fat_filelib.h fat_misc.c fat_misc.h fat_opts.h fat_string.c fat_string.h fat_table.c fat_table.h fat_types.h fat_write.c fat_write.h
  group FS/FRAM
    DMA_FAT/: fram.c fram.h fram_wr.c fram_wr.h
  group FS/MMC
    DMA_FAT/: dma_mmc.c dma_mmc.h dma_mmc_transaction.c dma_mmc_transaction.h
  group PLATFORM
    ./: define.h sys.c sys.h sys_adc.c sys_adc.h sys_gbl.c sys_isr.c sys_isr.h sys_rtc.c sys_rtc.h sys_rtcfun.s43 sys_spi.c sys_spi.h sys_timer.c sys_timer.h sys_uart.c sys_uart.h
    DMA_FAT/: dma_spi.c dma_spi.h
    $EW_DIR$/430/inc/: msp430x54x.h
  group STARTUP
    ./: main.c
  group SUPPORT
    DMA_FAT/: byte_queue.c byte_queue.h
    ./: convert.c convert.h probe.c probe.h switcher.c switcher.h typedefs.h
